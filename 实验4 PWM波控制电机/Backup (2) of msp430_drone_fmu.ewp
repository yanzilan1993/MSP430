# IAR project Backup (2) of msp430_drone_fmu.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: driverlib\MSP430F5xx_6xx; driverlib\MSP430F5xx_6xx\inc; src
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group driverlib/MSP430F5xx_6xx
    driverlib/MSP430F5xx_6xx/: adc10_a.c adc10_a.h adc12_a.c adc12_a.h aes.c aes.h battbak.c battbak.h comp_b.c comp_b.h crc.c crc.h ctsd16.c ctsd16.h dac12_a.c dac12_a.h dma.c dma.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h flashctl.c flashctl.h gpio.c gpio.h lcd_b.c lcd_b.h ldopwr.c ldopwr.h mpy32.c mpy32.h oa.c oa.h pmap.c pmap.h pmm.c pmm.h ram.c ram.h ref.c ref.h rtc_a.c rtc_a.h rtc_b.c rtc_b.h rtc_c.c rtc_c.h sd24_b.c sd24_b.h sfr.c sfr.h sysctl.c sysctl.h tec.c tec.h timer_a.c timer_a.h timer_b.c timer_b.h timer_d.c timer_d.h tlv.c tlv.h ucs.c ucs.h usci_a_spi.c usci_a_spi.h usci_a_uart.c usci_a_uart.h usci_b_i2c.c usci_b_i2c.h usci_b_spi.c usci_b_spi.h wdt_a.c wdt_a.h
  group driverlib/MSP430F5xx_6xx/inc
    driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
  group src
    src/: adc.c adc.h battery.c battery.h board.c board.h commapp.c commapp.h configtable.c configtable.h control.c control.h data_filter.c data_filter.h data_type.c data_type.h dbg.c dbg.h filter.c filter.h flash.c flash.h iic.c iic.h imu.c imu.h imuso3.c imuso3.h led.c led.h main.c motor.c motor.h mpu6050.c mpu6050.h nrf24l01.c nrf24l01.h port_int.c port_int.h rc.c rc.h timer.c timer.h usart.c usart.h
